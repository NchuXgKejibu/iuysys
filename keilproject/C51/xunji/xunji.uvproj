# Keil uVision project xunji.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: xunji +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\PWM;.\key
  group Source Group 1
    ./: STARTUP.A51 mian.c
  group pwm
    ./PWM/: PWM.c
  group key
    ./key/: key.c
