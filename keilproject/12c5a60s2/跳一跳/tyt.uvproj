# Keil uVision project tyt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: tyt +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\common;.\STC12C5A60S2
  group Source Group 1
    ./: STARTUP.A51 main.c
  group com
    ./common/: common.c
  group lib
    ./STC12C5A60S2/: lib.c
