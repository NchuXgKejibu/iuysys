# Keil uVision project pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pwm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\common;.\STC12C5A60S2
  group user
    ./: main.c
    ./common/: common.c
  group LIB
    ./STC12C5A60S2/: lib.c
